require dialog.inc

SRC_URI[md5sum] = "4b362a15cb72fb191165d5ece6d9ac16"
SRC_URI[sha256sum] = "1d98ec7cc81f11f9019fa0b90f1afdaa86579cae1ce8869a6fd61deb9d4b887a"
