PR = "openxt-01"

# TODO: Not necessary once using new meta-selinux repo
inherit pythonnative
