PR = "openxt-01"

# Make sure we use libgcrypt as we do not link it against libcap
PACKAGECONFIG = "gcrypt"
