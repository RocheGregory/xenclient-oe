PR = "openxt-01"

PACKAGECONFIG_class-native = "gnutls zlib"
