PR = "openxt-01"

DEPENDS_class-native = "zlib-native gnutls-native"
CURLGNUTLS_class-native = " --with-gnutls=${STAGING_LIBDIR}/ --without-ssl"
