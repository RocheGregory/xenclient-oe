DEPENDS_class-native += "gnutls-native"
CURLGNUTLS_class-native = " --with-gnutls=${STAGING_LIBDIR}/"
