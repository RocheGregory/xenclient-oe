LIC_FILES_CHKSUM = "file://Makefile.in;endline=14;md5=26dcddf37fa4c82d6b348ea74d99b0fe"

CFLAGS_append += " -Wno-sizeof-pointer-memaccess "
