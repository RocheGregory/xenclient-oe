require libdrm.inc

SRC_URI[md5sum] = "c3d31138d63e0edde3f5b93cd88fb93a"
SRC_URI[sha256sum] = "8b549092c8961a393a7e1d9a1bccddcea8e2af67c0d7d7c67babb9fc3b47699c"

